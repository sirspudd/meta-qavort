SRCREV = "${AUTOREV}"
KERNEL_VERSION_SANITY_SKIP = "1"
